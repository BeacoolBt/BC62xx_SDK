# Keil uVision project keil.uvprojx, settings and files
target sigmesh (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: keil +hex
  AfterMake: .\c.bat
  group device
    ../../../device/: bc_sys.c system.c systick.c
  group drivers
    ../../../drivers/led/: led.c
    ../../../drivers/hal/: bc_flash.c bc62xx_ble.c bc62xx_flash.c bc62xx_gpio.c bc62xx_pwm.c bc62xx_timer.c bc62xx_uart.c
    ../../../drivers/ble/: ble_adv.c
    ../../../drivers/ProtocolResolution/: ProtocolRln.c
  group mesh
    ../../../mesh/app/ali_light/: ali_light.c
    ../../../mesh/app/ali_socket/: ali_socket.c
    ../../../mesh/app/: ali_config.c app_mesh.c
    ../../../../BC6218/mesh/app/ali_HeatingTable/: ali_HeatingTable.c
  group sigmesh
    ../src/: gatt_ota.c main.c
  group start
    ../../../: startup_m0.s
  group primesh
    ../PriMesh/: Application.c PriMesh.c Timer.c Function.c
