# Keil uVision project keil.uvprojx, settings and files
target sigmesh (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: keil +hex
  AfterMake: .\c.bat
  group device
    ../../../device/: system.c bc_sys.c systick.c
  group drivers
    ../../../drivers/hal/: bc62xx_gpio.c bc62xx_uart.c bc62xx_timer.c
    ../../../drivers/ProtocolResolution/: ProtocolRln.c
  group uart
    ../src/: main.c
  group start
    ../../../: startup_m0.s
